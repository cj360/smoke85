# Repository cj360/smoke85

## KiCad design smoke85/smoke85.kicad_pcb

Board: 2 copper layers, 20.3 x 50.8 mm, 23 parts (0 on the bottom side), 46 nets.

Parts:
BOOT1: SW_SPST; SW_SPST_TL3342
C1, C3, C4, C5, C6, C7, C8: 100nF; C_0402_1005Metric
C2: 10uF; C_0603_1608Metric
C9, C10: 1uF; C_0402_1005Metric
F1: 500mA; Fuse_1206_3216Metric
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2, J3: Conn_01x20; PinHeader_1x20_P2.54mm_Vertical
R1, R2, R3, R4: 5.1k; R_0402_1005Metric
RST1: SW_SPST; SW_SPST_TL3342
U1: STM32F072CBT6; LQFP-48_7x7mm_P0.5mm
U2: PRTR5V0U2X; SOT-143
U3: XC6206PxxxMR-Regulator_Linear; SOT-23

Connections:
+3V3: BOOT1.1 (A), C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C10.1, J2.5, U1.1 (VBAT), U1.9 (VDDA), U1.24 (VDD), U1.36 (VDDIO2), U1.48 (VDD), U3.2 (VO)
+5V: C8.1, C9.1, F1.2, U2.4 (VCC), U3.3 (VI)
/A0: J3.20, U1.10 (PA0)
/A1: J3.19, U1.11 (PA1)
/A2: J3.18, U1.12 (PA2)
/A3: J3.17, U1.13 (PA3)
/A4: J3.16, U1.14 (PA4)
/A5: J3.15, U1.15 (PA5)
/A6: J3.14, U1.16 (PA6)
/A7: J3.13, U1.17 (PA7)
/A8: J3.3, U1.29 (PA8)
/A9: J3.2, U1.30 (PA9)
/A10: J3.1, U1.31 (PA10)
/A13: J2.6, U1.34 (PA13)
/A14: J2.7, U1.37 (PA14)
/A15: J2.8, U1.38 (PA15)
/B0: J3.12, U1.18 (PB0)
/B1: J3.11, U1.19 (PB1)
/B2: J3.10, U1.20 (PB2)
/B3: J2.9, U1.39 (PB3)
/B4: J2.10, U1.40 (PB4)
/B5: J2.11, U1.41 (PB5)
/B6: J2.12, U1.42 (PB6)
/B7: J2.13, U1.43 (PB7)
/B8: J2.14, U1.45 (PB8)
/B9: J2.15, U1.46 (PB9)
/B10: J3.9, U1.21 (PB10)
/B11: J3.8, U1.22 (PB11)
/B12: J3.7, U1.25 (PB12)
/B13: J3.6, U1.26 (PB13)
/B14: J3.5, U1.27 (PB14)
/B15: J3.4, U1.28 (PB15)
/C13: J2.16, U1.2 (PC13)
/C14: J2.17, U1.3 (PC14)
/C15: J2.18, U1.4 (PC15)
/F0: J2.19, U1.5 (PF0)
/F1: J2.20, U1.6 (PF1)
BOOT0: BOOT1.2 (B), J2.4, R3.1, U1.44 (BOOT0)
D+: J1.A6 (D+), J1.B6 (D+), U1.33 (PA12)
D-: J1.A7 (D-), J1.B7 (D-), U1.32 (PA11)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2, R1.1, R2.2, R4.2, RST1.2 (B), U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.1 (GND), U3.1 (GND)
NRST: C1.1, J2.3, RST1.1 (A), U1.7 (NRST)
unnamed: J1.A5 (CC1), R1.2
unnamed: J1.B5 (CC2), R2.1
unnamed: R3.2, R4.1
VBUS: F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.1

## Commit log (part)

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2026-04-07 start kicad project
2026-04-08 start connecting rgb leds
2026-04-19 wire more leds
